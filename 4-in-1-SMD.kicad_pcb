# Repository rkrenicki/Tandy-EX-HX-4in1

File README.md:

# Tandy 1000 EX/HX 4-in-1 Expansion Board

This is a single expansion board designed for the Tandy 1000 EX and HX computers, to include the following upgrades:

* 640KB Base System Memory and 96KB Upper Memory
* 16550-based DE9 Serial RS232 Port
* XT-IDE based CompactFlash "Hard Drive"
* Integrated DS1315 "Smartwatch" Real Time Clock (Optional)

This is an SMD variant of my original "Tandy 1000 EX/HX 3-in-1" which I was able to shrink down to 100x100mm.  With the space that I had left over, I added provisions for an optional DS1315 based "Smartwatch" RTC, and added a bus passthrough header.

## Prerequisites

This board is for the Tandy 1000EX and 1000HX computers only.  It will not work in any other computer model as it is.
You must remove any expansion cards already in the computer, this is designed to be a single-board upgrade but does have a "passthrough" to allow for a second card to be installed.

## Installing

This board plugs into the Tandy PLUS interface, and takes up "Slot 2" on the rear of the computer.  Please be careful to align the PLUS bus connector before pushing down, to avoid bending pins on the computer.  Secure the backplate to the computer with two screws.
The IDE BIOS will automatically start and boot directly to the CF card on 1000EX machines.   1000HX loads a boot menu by default, and you will need to press F4 to load the IDE BIOS.  If you want to bypass the Tandy DOS ROM and boot menu, run "SETUPHX" and change the "Primary Start-up Device" to "DISK" and press F1 to save.

## Technical Details

This board has no configuration jumpers and is designed to be plug-and-play.  The only jumper is to enable programming the ROM.  Install the jumper to flash the XT-IDE BIOS, otherwise the jumper should be removed.  All assembled boards and kits sold by me come with a pre-programmed ROM, and this jumper should be left empty.

The board is hardwired with these memory locations/ports:
```
SRAM:  0x0000-0x5FFF, 0xC800-0xDFFF
UART:  0x3F8, IRQ 4
IDE:   0x300
ROM:   0xC000-0xC7FF
```

## Assembly Notes
All functions of the board are independent, no parts are shared between functions.  If you do not want to use a specific function, you can safely omit any parts referenced with the function in the name (such as "232" for RS232).

NOTE:  Please take careful note of part orientation.  To optimize some trace routing, not all chips are oriented in the same direction.  

If you opt to not install the RTC, leave out RTC-U15, RTC-Y1, RTC-BT1 and its holder, and install a solder blob on JP2.

## Bill of Materials
|Quan |Ref(s)        |Package | Mouser Part Number  |Description                                                     
|-----|--------------|--------|---------------------|----------------------------------------------------------------
| 1   |BUS1          | TH     |200-CES13101SD<br><b><i>See note below</i></b>|2x31 2.54mm Header Socket
| 1   |CF-J1         | TH     |517-8540-4500PL<br><b><i>See note below</i></b>|2x20 2.54mm Header Socket, 11mm height.
| 3   |R1 through R3 | 0603   |603-RC0603FR-0710KL  |10kOhm Resistor
| 1   |CP1           | TH     |667-ECA-1AM101I      |100uF 16V Electrolytic, 2.5mm LS
| 17  |C1 through C17| 0603   |963-EMK107B7104KAHT  |0.1uF Multilayer Ceramic Capacitor
| 2   |232-U7, 232-U9| SO16   |863-MC74ACT138DG     |3 to 8 Line Demux
| 2   |CF-U3, RAM-U11| SO20W  |863-MC74HCT245ADWG   |Tri-state Bus Transciever
| 1   |RAM-U13       | SO14   |595-SN74HCT32DR      |Quad OR Gate
| 1   |RAM-U12       | SO14   |595-SN74HCT00DR      |Quad NAND Gate
| 1   |CF-U1         | SO16   |863-MC74ACT139DG     |Dual 2 to 4 Demux
| 1   |232-U6        | SO20   |595-GD75232DBR       |RS-232 Driver
| 2   |CF-U2, ROM-U4 | SO20W  |595-CD74HCT688M96    |8 Bit Comparator
| 1   |232-P2        | TH     |523-L717SDE09PA4CH4  |RS232 DE9 Connector
| 1   |232-OSC1      |        |774-CB3-3C-1M8432    |1.8432Mhz Oscillator 0705 TTL
| 1   |232-U8        | LQFP48 |595-TL16C550DPFBR    |RS-232 UART
| 1   |RAM-U10       | SOP32  |913-AS6C4008-55SIN   |4mbit SRAM  (512K x 8)
| 1   |ROM-U5        | DIP32  |804-39SF010A7CPHE    |1mbit Flash
| 1   |ROM-U5 Socket | DIP32  |517-4832-6000-CP     |32pin wide DIP socket
| 1   |RTC-U15       | SO16   |700-DS1315S-5        |Real Time Clock Phantom Time Chip
| 1   |RTC-Y1        | TH     |695-CFS-20632768DZBB |32.768kHz Cylinder Crystal
| 1   |RTC-BT1       | n/a    |81-CR1216            |CR1216 Battery
| 1   |RTC-BT1 Socket| TH     |534-3001             |12mm Surface Battery Holder
| 1   |CF-IDE Adapter| n/a    |n/a                  |CF to IDE Adapter from eBay or AliExpress (See note below)
| 1   |Mounting Tab  | n/a    |534-7327             |Mounting Tab for backplate (optional)

Note: For the BUS1 Connectors, I have many of these left over from my last order of custom connectors.   You can buy them from me for $1/ea plus shipping.  Even for one, it is far cheaper than the $13 that Mouser wants.   
For small quantities (1-20 connectors), visit my Tindie store to order:  https://www.tindie.com/products/rkrenicki/tandy-1000-ex-and-hx-bus-connector/
For larger quantities, please email tandy.3in1@gmail.com.

## BIOS

This board uses the XT-IDE Universal BIOS.  I have included pre-configured images for 2.0.0B3 r602 (latest version as of the time of writing this).  The 3in1BIOS-8088.zip will work on any EX or HX computer, and is the version that I preload on assembled boards and kits.   I have also included a V20 Enhanced version for any EX/HX that has an NEC V20 (or clone) installed.   This enhanced version will roughly double your disk speed, but only works on V20 machines.

## CF-IDE Adapter

This board is designed a specific version of a CF-IDE adapter.  They are widely available on eBay and AliExpress.  It bears the mark of "IDE to CF Ver.D2".  It can generally be identified by the metal cover over the CF card connector.   I do not have a link to any one specific vendor or listing, but if the adapter includes the metal backplate and has a metal cover over the CF slot, then it should be correct. 

The CF adapter does also need a few modifications, please refer to the "IDE Adapter Modifications.pdf" for details.  It also has photos of the adapter for reference to buy the proper adapter.

If you have any questions, feel free to join the Discord server below and ask in the #tandy-3in1-support channel.

## Support Discord

I have started a Discord server for more real-time technical support, as well as discussion for my various projects in progress.   You can follow this link to join:  https://discord.gg/QmFssyXnQt

## Built With

* [KiCAD EDA](http://www.kicad-pcb.org/)

## Authors

* **Rob Krenicki** - [rkrenicki](https://github.com/rkrenicki)

## License

This project is licensed under the Creative Commons - Attribution - ShareAlike 3.0 License

## Attribution

This board was derrived from works by, uses design elements from, or contains sofware writen by the following:
* Sergey Kiselev (http://www.malinov.com/Home/sergeys-projects)
* James Pearce (https://www.lo-tech.co.uk/)
* Adrian Black (https://www.youtube.com/user/craig1black/featured)
* Jacob Dorne of Monotech PCs (https://monotech.fwscart.com/)
* Derek Osborne (
* XTIDE Universal BIOS Team (http://www.xtideuniversalbios.org/)

## README TO-DO
* Assembly Instructions

## KiCad design 4-in-1-SMD.kicad_pcb

Parts:
232-OSC1: 1.8432MHz; Oscillator_SMD_SeikoEpson_SG8002CA-4Pin_7.0x5.0mm_HandSolde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; LCSC C386895
232-P2: SERIAL; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_Hou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
232-U6: GD75232; SSOP-20_5.3x7.2mm_P0.65mm; LCSC C171524
232-U7, 232-U9: 74LS138; SOIC-16_3.9x9.9mm_P1.27mm; LCSC C7736
232-U8: 16C550; LQFP-48_7x7mm_P0.5mm; LCSC C181382
BUS1, BUS2: TANDY_BUS; TANDY-PLUS-BUS
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C1760
CF-J1: CF Interface; PinSocket_2x20_P2.54mm_Vertical
CF-J2: CF Power; PinSocket_1x02_P2.54mm_Vertical
CF-U1: 74LS139; SOIC-16_3.9x9.9mm_P1.27mm; LCSC C5494
CF-U2: 74LS688; SOIC-20W_7.5x12.8mm_P1.27mm
CF-U3: 74LS245; SOIC-20W_7.5x12.8mm_P1.27mm; LCSC C7409
CP1: 100uF; CP_Radial_D5.0mm_P2.50mm
H1, H2: MountingHole; MountingHole_2.7mm_M2.5_ISO7380_Pad
JP1: Jumper; PinHeader_1x02_P2.54mm_Vertical
JP2: No-RTC Enable; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R1, R2, R3: 10K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C114851
RAM-U10: AS6C4008-55SIN; SSOP-32_11.305x20.495mm_P1.27mm
RAM-U11: 74LS245; SOIC-20W_7.5x12.8mm_P1.27mm; LCSC C7409
RAM-U12: 74LS00; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C5956
RAM-U13: 74LS32; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C5985
ROM-U4: 74LS688; SOIC-20W_7.5x12.8mm_P1.27mm
ROM-U5: 39SF0x0; DIP-32_W15.24mm_Socket
RTC-BT1: CR1220; BatteryHolder_Keystone_3001_1x12mm
RTC-U15: DS1315; SOP-16_7.5x10.4mm_P1.27mm
RTC-Y1: 32.768kHz; Crystal_DS10_D1.0mm_L4.3mm_Horizontal

Connections:
+5V: 232-OSC1.1 (Tri-State), 232-OSC1.4 (VDD), 232-U6.20 (VCC), 232-U7.6 (G1), 232-U7.16 (VCC), 232-U8.9 (CS0), 232-U8.10 (CS1), 232-U8.42 (VCC), 232-U9.16 (VCC), BUS1.34 (+5V), BUS1.60 (+5V), BUS2.34 (+5V), BUS2.60 (+5V), C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, CF-J2.1, CF-U1.16 (VCC), CF-U2.3 (Q0), CF-U2.5 (Q1), CF-U2.20 (VCC), CF-U3.20 (VCC), CP1.1, R1.1, R2.1, RAM-U10.32 (VCC), RAM-U11.20 (VCC), RAM-U12.14 (VCC), RAM-U13.14 (VCC), ROM-U4.3 (Q0), ROM-U4.5 (Q1), ROM-U4.20 (VCC), ROM-U5.32 (VCC), RTC-U15.13 (RST), RTC-U15.16 (VCC1)
+12V: 232-U6.1 (VDD), BUS1.40 (+12V), BUS2.40 (+12V), C17.1
-12V: 232-U6.10 (VSS), BUS1.38 (-12V), BUS2.38 (-12V), C16.2
A0: 232-U8.28 (A0), BUS1.31 (A0), BUS2.31 (A0), RAM-U10.12 (A0), ROM-U5.12 (A0), RTC-U15.6 (D)
A1: 232-U8.27 (A1), BUS1.30 (A1), BUS2.30 (A1), CF-J1.35, RAM-U10.11 (A1), ROM-U5.11 (A1)
A2: 232-U8.26 (A2), BUS1.29 (A2), BUS2.29 (A2), CF-J1.33, RAM-U10.10 (A2), ROM-U5.10 (A2), RTC-U15.3 (/WE)
A3: 232-U9.3 (C), BUS1.28 (A3), BUS2.28 (A3), CF-J1.36, RAM-U10.9 (A3), ROM-U5.9 (A3)
A4: 232-U9.2 (B), BUS1.27 (A4), BUS2.27 (A4), CF-U1.2 (A0), RAM-U10.8 (A4), ROM-U5.8 (A4)
A5: 232-U9.6 (G1), BUS1.26 (A5), BUS2.26 (A5), CF-U2.11 (P4), RAM-U10.7 (A5), ROM-U5.7 (A5)
A6: 232-U7.1 (A), BUS1.25 (A6), BUS2.25 (A6), CF-U2.8 (P3), RAM-U10.6 (A6), ROM-U5.6 (A6)
A7: 232-U7.2 (B), BUS1.24 (A7), BUS2.24 (A7), CF-U2.6 (P2), RAM-U10.5 (A7), ROM-U5.5 (A7)
A8: 232-U9.1 (A), BUS1.23 (A8), BUS2.23 (A8), CF-U2.4 (P1), RAM-U10.23 (A10), ROM-U5.27 (A8)
A9: 232-U7.3 (C), BUS1.22 (A9), BUS2.22 (A9), CF-U2.2 (P0), RAM-U10.25 (A11), ROM-U5.26 (A9)
A10: BUS1.21 (A10), BUS2.21 (A10), RAM-U10.26 (A9), ROM-U5.23 (A10)
A11: BUS1.20 (A11), BUS2.20 (A11), RAM-U10.27 (A8), ROM-U5.25 (A11)
A12: BUS1.19 (A12), BUS2.19 (A12), RAM-U10.28 (A13), ROM-U5.4 (A12)
A13: BUS1.18 (A13), BUS2.18 (A13), RAM-U10.30 (A17), ROM-U5.28 (A13)
A14: BUS1.17 (A14), BUS2.17 (A14), RAM-U10.31 (A15), ROM-U5.29 (A14)
A15: BUS1.16 (A15), BUS2.16 (A15), RAM-U10.4 (A12), RAM-U13.5, ROM-U4.11 (P4)
A16: BUS1.15 (A16), BUS2.15 (A16), RAM-U10.3 (A14), RAM-U13.4, ROM-U4.8 (P3)
A17: BUS1.14 (A17), BUS2.14 (A17), RAM-U12.13, RAM-U13.2, ROM-U4.6 (P2)
A18: BUS1.13 (A18), BUS2.13 (A18), RAM-U10.1 (A18), RAM-U12.9, RAM-U12.12, ROM-U4.4 (P1)
A19: BUS1.12 (A19), BUS2.12 (A19), RAM-U12.1, RAM-U13.1, ROM-U4.2 (P0)
AEN: 232-U9.4 (~G2A), BUS1.11 (AEN), BUS2.11 (AEN), CF-U2.1 (~G)
ALE: BUS1.59 (ALE), BUS2.59 (ALE)
BREQ: BUS1.53 (BREQ), BUS2.53 (BREQ)
CFD0: CF-J1.17, CF-U3.18 (B0)
CFD1: CF-J1.15, CF-U3.17 (B1)
CFD2: CF-J1.13, CF-U3.16 (B2)
CFD3: CF-J1.11, CF-U3.15 (B3)
CFD4: CF-J1.9, CF-U3.14 (B4)
CFD5: CF-J1.7, CF-U3.13 (B5)
CFD6: CF-J1.5, CF-U3.12 (B6)
CFD7: CF-J1.3, CF-U3.11 (B7)
CF_CS0: CF-J1.37, CF-U1.4 (O0)
CF_CS1: CF-J1.38, CF-U1.5 (O1)
CF_RESET: CF-J1.1, CF-U1.11 (O1)
CLK: BUS1.51 (CLK), BUS2.51 (CLK)
D0: 232-U8.43 (D0), BUS1.9 (D0), BUS2.9 (D0), CF-U3.2 (A0), RAM-U11.2 (A0), ROM-U5.13 (D0), RTC-U15.7 (Q)
D1: 232-U8.44 (D1), BUS1.8 (D1), BUS2.8 (D1), CF-U3.3 (A1), RAM-U11.3 (A1), ROM-U5.14 (D1)
D2: 232-U8.45 (D2), BUS1.7 (D2), BUS2.7 (D2), CF-U3.4 (A2), RAM-U11.4 (A2), ROM-U5.15 (D2)
D3: 232-U8.46 (D3), BUS1.6 (D3), BUS2.6 (D3), CF-U3.5 (A3), RAM-U11.5 (A3), ROM-U5.17 (D3)
D4: 232-U8.47 (D4), BUS1.5 (D4), BUS2.5 (D4), CF-U3.6 (A4), RAM-U11.6 (A4), ROM-U5.18 (D4)
D5: 232-U8.2 (D5), BUS1.4 (D5), BUS2.4 (D5), CF-U3.7 (A5), RAM-U11.7 (A5), ROM-U5.19 (D5)
D6: 232-U8.3 (D6), BUS1.3 (D6), BUS2.3 (D6), CF-U3.8 (A6), RAM-U11.8 (A6), ROM-U5.20 (D6)
D7: 232-U8.4 (D7), BUS1.2 (D7), BUS2.2 (D7), CF-U3.9 (A7), RAM-U11.9 (A7), ROM-U5.21 (D7)
DMATC: BUS1.58 (DMATC), BUS2.58 (DMATC)
FDCDACK: BUS1.57 (FDCDACK), BUS2.57 (FDCDACK)
FDCDMRQ: BUS1.37 (FDCDMRQ), BUS2.37 (FDCDMRQ)
GND: 232-OSC1.2 (GND), 232-P2.0 (Shell), 232-P2.5, 232-U6.11 (GND), 232-U7.4 (~G2A), 232-U7.5 (~G2B), 232-U7.8 (GND), 232-U8.17 (WR), 232-U8.18 (GND), 232-U8.20 (RD), 232-U8.24 (~ADS), 232-U9.8 (GND), BUS1.32 (GND), BUS1.41 (GND), BUS1.62 (GND), BUS2.32 (GND), BUS2.41 (GND), BUS2.62 (GND), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.1, C17.2, CF-J1.2, CF-J1.19, CF-J1.22, CF-J1.24, CF-J1.26, CF-J1.30, CF-J1.40, CF-J2.2, CF-U1.3 (A1), CF-U1.8 (GND), CF-U1.13 (A1), CF-U1.15 (E), CF-U2.7 (Q2), CF-U2.9 (Q3), CF-U2.10 (GND), CF-U2.12 (Q4), CF-U2.13 (P5), CF-U2.14 (Q5), CF-U2.15 (P6), CF-U2.16 (Q6), CF-U2.17 (P7), CF-U2.18 (Q7), CF-U3.10 (GND), CP1.2, H1.1, H2.1, R3.1, RAM-U10.16 (VSS), RAM-U11.10 (GND), RAM-U12.7 (GND), RAM-U13.7 (GND), RAM-U13.9, RAM-U13.10, RAM-U13.12, RAM-U13.13, ROM-U4.1 (~G), ROM-U4.7 (Q2), ROM-U4.9 (Q3), ROM-U4.10 (GND), ROM-U4.12 (Q4), ROM-U4.13 (P5), ROM-U4.14 (Q5), ROM-U4.15 (P6), ROM-U4.16 (Q6), ROM-U4.17 (P7)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
IRQ2: BUS1.35 (IRQ2), BUS2.35 (IRQ2)
IRQ3: BUS1.56 (IRQ3), BUS2.56 (IRQ3)
IRQ4: 232-U8.30 (INTR), BUS1.55 (IRQ4), BUS2.55 (IRQ4)
MEM-CE: RAM-U10.22 (CE#), RAM-U11.19 (CE), RAM-U12.6
MEMD0: RAM-U10.13 (DQ0), RAM-U11.18 (B0)
MEMD1: RAM-U10.14 (DQ1), RAM-U11.17 (B1)
MEMD2: RAM-U10.15 (DQ2), RAM-U11.16 (B2)
MEMD3: RAM-U10.17 (DQ3), RAM-U11.15 (B3)
MEMD4: RAM-U10.18 (DQ4), RAM-U11.14 (B4)
MEMD5: RAM-U10.19 (DQ5), RAM-U11.13 (B5)
MEMD6: RAM-U10.20 (DQ6), RAM-U11.12 (B6)
MEMD7: RAM-U10.21 (DQ7), RAM-U11.11 (B7)
NMI: BUS1.1 (NMI), BUS2.1 (NMI)
unnamed: 232-OSC1.3 (OUT), 232-U8.14 (XIN)
unnamed: 232-P2.1, 232-U6.2 (RA1)
unnamed: 232-P2.2, 232-U6.4 (RA3)
unnamed: 232-P2.3, 232-U6.6 (DY2)
unnamed: 232-P2.4, 232-U6.8 (DY3)
unnamed: 232-P2.6, 232-U6.3 (RA2)
unnamed: 232-P2.7, 232-U6.5 (DY1)
unnamed: 232-P2.8, 232-U6.7 (RA4)
unnamed: 232-P2.9, 232-U6.9 (RA5)
unnamed: 232-U6.12 (RY5), 232-U8.41 (~RI)
unnamed: 232-U6.13 (DA3), 232-U8.33 (~DTR)
unnamed: 232-U6.14 (RY4), 232-U8.38 (~CTS)
unnamed: 232-U6.15 (DA2), 232-U8.8 (SOUT)
unnamed: 232-U6.16 (DA1), 232-U8.32 (~RTS)
unnamed: 232-U6.17 (RY3), 232-U8.7 (SIN)
unnamed: 232-U6.18 (RY2), 232-U8.39 (~DSR)
unnamed: 232-U6.19 (RY1), 232-U8.40 (~DCD)
unnamed: 232-U7.7 (~Y7), 232-U9.5 (~G2B)
unnamed: 232-U8.5 (RCLK), 232-U8.12 (~BAUDOUT)
unnamed: CF-J1.21, R3.2
unnamed: CF-J1.27, R2.2
unnamed: CF-U1.1 (E), CF-U2.19 (~P=Q), CF-U3.19 (CE)
unnamed: JP1.1, R1.2, ROM-U5.31 (PGM)
unnamed: RAM-U12.2, RAM-U12.8
unnamed: RAM-U12.3, RAM-U12.4
unnamed: RAM-U12.10, RAM-U13.6
unnamed: RAM-U12.5, RAM-U12.11
unnamed: RTC-BT1.1 (+), RTC-U15.4 (BAT1)
unnamed: RTC-U15.1 (X1), RTC-Y1.1
unnamed: RTC-U15.2 (X2), RTC-Y1.2
unnamed: RTC-U15.9 (ROM/RAM), RTC-U15.15 (VCC0)
OSC: BUS1.61 (OSC), BUS2.61 (OSC)
RDYIN: BUS1.10 (RDYIN), BUS2.10 (RDYIN)
REFRESH: BUS1.50 (REFRESH), BUS2.50 (REFRESH)
RESETDRV: 232-U8.35 (MR), BUS1.33 (RESET), BUS2.33 (RESET), CF-U1.14 (A0)
RFSH: BUS1.52 (RFSH), BUS2.52 (RFSH)
SR-A17: RAM-U10.2 (A16), RAM-U13.3
U36: BUS1.36 (UNUSED), BUS2.36 (UNUSED)
U39: BUS1.39 (UNUSED), BUS2.39 (UNUSED)
U46: BUS1.46 (UNUSED), BUS2.46 (UNUSED)
U47: BUS1.47 (UNUSED), BUS2.47 (UNUSED)
U48: BUS1.48 (UNUSED), BUS2.48 (UNUSED)
U49: BUS1.49 (UNUSED), BUS2.49 (UNUSED)
U54: BUS1.54 (UNUSED), BUS2.54 (UNUSED)
~IOR: 232-U8.19 (~RD), BUS1.45 (IOR), BUS2.45 (IOR), CF-J1.25, CF-U3.1 (A->B)
~IOW: 232-U8.16 (~WR), BUS1.44 (IOW), BUS2.44 (IOW), CF-J1.23
~MEMR: BUS1.43 (MEMR), BUS2.43 (MEMR), RAM-U10.24 (OE#), RAM-U11.1 (A->B), ROM-U5.24 (OE), RTC-U15.12 (OE)
~MEMW: BUS1.42 (MEMW), BUS2.42 (MEMW), JP1.2, RAM-U10.29 (WE#)
~ROM_CS: JP2.1, ROM-U5.22 (CE), RTC-U15.10 (CEO)
~RTC_CS: JP2.2, ROM-U4.19 (~P=Q), RTC-U15.11 (CEI)
~UART_CS: 232-U8.11 (~CS2), 232-U9.7 (~Y7)

Notes on the sheet:
Compact Flash (0x300)
RTC (0xC000)
RS232 Serial Controller
Static RAM
Tandy PLUS Bus
BIOS ROM (0xC000)
Power, Spares, and Bypass Capacitors

Board: 2 copper layers, 100.0 x 100.0 mm, 47 parts (0 on the bottom side), 114 nets.

## Commit log

2020-08-09 excess file removal
2020-08-22 Instructions
2021-07-27 RTC Bypass Jumper
    Adds solder jumper for omission of Smartwatch RTC parts.
2021-09-27 BIOS
2025-11-08 Update to KiCAD 9.0
    Updated to KiCAD 9.0. Regenerated Gerber for missing JP2
